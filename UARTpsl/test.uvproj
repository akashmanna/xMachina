# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c c_func.c a_func.a51
